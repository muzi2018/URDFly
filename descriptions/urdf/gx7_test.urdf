Commit message: optimize chain display and handle virtual links

File: descriptions/urdf/gx7_test.urdf (robot description, URDF)
Before this commit: robot GX7_250721, 8 links, 7 joints
Links:
- link Link7: geometry 
